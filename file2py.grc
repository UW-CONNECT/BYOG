options:
  parameters:
    generate_options: qt_gui
    id: file2py
    output_language: python
    title: ID
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C2
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C3
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C4
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_3
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C5
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_4
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C6
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_5
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C7
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_6
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C8
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_7
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C9
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_8
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C10
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_3
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_4
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_5
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_6
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_7
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_8
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_3
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_4
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_5
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_6
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_7
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_8
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2010'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '1998'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2020'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2030'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5100'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2050'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2040'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2060'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2070'
    send_eof: 'False'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_5, '0']
- [blocks_file_source_0_1, '0', blocks_throttle2_0_1, '0']
- [blocks_file_source_0_1, '0', blocks_throttle_0_4, '0']
- [blocks_file_source_0_2, '0', blocks_throttle2_0_2, '0']
- [blocks_file_source_0_2, '0', blocks_throttle_0_3, '0']
- [blocks_file_source_0_3, '0', blocks_throttle2_0_3, '0']
- [blocks_file_source_0_3, '0', blocks_throttle_0_2, '0']
- [blocks_file_source_0_4, '0', blocks_throttle2_0_4, '0']
- [blocks_file_source_0_4, '0', blocks_throttle_0_1, '0']
- [blocks_file_source_0_5, '0', blocks_throttle2_0_5, '0']
- [blocks_file_source_0_5, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_6, '0', blocks_throttle2_0_6, '0']
- [blocks_file_source_0_6, '0', blocks_throttle_0_6, '0']
- [blocks_file_source_0_7, '0', blocks_throttle2_0_7, '0']
- [blocks_file_source_0_7, '0', blocks_throttle_0_7, '0']
- [blocks_file_source_0_8, '0', blocks_throttle2_0_8, '0']
- [blocks_file_source_0_8, '0', blocks_throttle_0_8, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0_0_1_0_0_0, '0']
- [blocks_throttle2_0_0, '0', network_udp_sink_0_0_1_0_0, '0']
- [blocks_throttle2_0_1, '0', network_udp_sink_0_0_1_0, '0']
- [blocks_throttle2_0_2, '0', network_udp_sink_0_0_1, '0']
- [blocks_throttle2_0_3, '0', network_udp_sink_0_0, '0']
- [blocks_throttle2_0_4, '0', network_udp_sink_0_0_0, '0']
- [blocks_throttle2_0_5, '0', network_udp_sink_0_0_0_0, '0']
- [blocks_throttle2_0_6, '0', network_udp_sink_0_0_0_0_0, '0']
- [blocks_throttle2_0_7, '0', network_udp_sink_0_0_0_0_0_0, '0']
- [blocks_throttle2_0_8, '0', network_udp_sink_0_0_1_0_0_1, '0']
- [blocks_throttle_0, '0', network_udp_sink_0_0_1_0_0_0, '0']
- [blocks_throttle_0_0, '0', network_udp_sink_0_0_0_0, '0']
- [blocks_throttle_0_1, '0', network_udp_sink_0_0_0, '0']
- [blocks_throttle_0_2, '0', network_udp_sink_0_0, '0']
- [blocks_throttle_0_3, '0', network_udp_sink_0_0_1, '0']
- [blocks_throttle_0_4, '0', network_udp_sink_0_0_1_0, '0']
- [blocks_throttle_0_5, '0', network_udp_sink_0_0_1_0_0, '0']
- [blocks_throttle_0_6, '0', network_udp_sink_0_0_0_0_0, '0']
- [blocks_throttle_0_7, '0', network_udp_sink_0_0_0_0_0_0, '0']
- [blocks_throttle_0_8, '0', network_udp_sink_0_0_1_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
