options:
  parameters:
    author: Patron
    generate_options: qt_gui
    id: Chan10_4M_HackRF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FBtaps
  id: variable
  parameters:
    value: '[1        , -3.88339325,  5.66830702, -3.68542089,  0.90054539]'
  states: {}
- name: FFtaps
  id: variable
  parameters:
    value: '[2.17221527e-06, 8.52742489e-06, 1.27119330e-05, 8.52742489e-06, 2.17221527e-06]'
  states: {}
- name: FSby2
  id: variable
  parameters:
    value: samp_rate/(2e6)
  states: {}
- name: M_PI
  id: variable
  parameters:
    value: '3.14159265358979323846'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\test
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C5
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C4
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C7
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C9
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C1
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C3
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C6
    type: complex
  states: {}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C8
    type: complex
  states: {}
- name: blocks_file_sink_0_0_2_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C10
    type: complex
  states: {}
- name: blocks_file_sink_0_0_2_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C2
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.1 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.1 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.3 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.3 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.7 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.5 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_1_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.9 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_1_2
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.9 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.5 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.7 * M_PI) / FSby2
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_1_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_2
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1_3
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_2
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_3
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2010'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '1998'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2020'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2030'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5100'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2050'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2040'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2060'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2070'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_3
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_4
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_5
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_6
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_6_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_6_1
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: 903.2e6
    gain: '40'
    samp_rate: samp_rate
    type: fc32
    vga: '12'
  states: {}

connections:
- [blocks_correctiq_0, '0', blocks_rotator_cc_0, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0_0, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0_1, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0_1_0, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0_1_1, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_0_1_2, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_1, '0']
- [blocks_correctiq_0, '0', blocks_rotator_cc_0_0_1_0, '0']
- [blocks_rotator_cc_0, '0', iir_filter_xxx_0_0_0, '0']
- [blocks_rotator_cc_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_rotator_cc_0_0_0, '0', iir_filter_xxx_0_0_1, '0']
- [blocks_rotator_cc_0_0_0_0, '0', iir_filter_xxx_0_0_1_0, '0']
- [blocks_rotator_cc_0_0_0_1, '0', iir_filter_xxx_0_0_1_1, '0']
- [blocks_rotator_cc_0_0_0_1_0, '0', iir_filter_xxx_0_0_1_1_0, '0']
- [blocks_rotator_cc_0_0_0_1_1, '0', iir_filter_xxx_0_0_1_1_2, '0']
- [blocks_rotator_cc_0_0_0_1_2, '0', iir_filter_xxx_0_0_1_1_3, '0']
- [blocks_rotator_cc_0_0_1, '0', iir_filter_xxx_0_0_2, '0']
- [blocks_rotator_cc_0_0_1_0, '0', iir_filter_xxx_0_0_2_0, '0']
- [iir_filter_xxx_0_0, '0', iir_filter_xxx_0_0_3, '0']
- [iir_filter_xxx_0_0_0, '0', iir_filter_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0_0_1, '0', iir_filter_xxx_0_0_1_2, '0']
- [iir_filter_xxx_0_0_1_0, '0', iir_filter_xxx_0_0_1_0_0, '0']
- [iir_filter_xxx_0_0_1_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [iir_filter_xxx_0_0_1_1, '0', iir_filter_xxx_0_0_1_1_1, '0']
- [iir_filter_xxx_0_0_1_1_0, '0', iir_filter_xxx_0_0_1_1_0_0, '0']
- [iir_filter_xxx_0_0_1_1_0_0, '0', rational_resampler_xxx_0_0, '0']
- [iir_filter_xxx_0_0_1_1_1, '0', rational_resampler_xxx_0_0_0_6, '0']
- [iir_filter_xxx_0_0_1_1_1_0, '0', rational_resampler_xxx_0_0_0_6_0, '0']
- [iir_filter_xxx_0_0_1_1_1_1, '0', rational_resampler_xxx_0_0_0_6_1, '0']
- [iir_filter_xxx_0_0_1_1_2, '0', iir_filter_xxx_0_0_1_1_1_0, '0']
- [iir_filter_xxx_0_0_1_1_3, '0', iir_filter_xxx_0_0_1_1_1_1, '0']
- [iir_filter_xxx_0_0_1_2, '0', rational_resampler_xxx_0_0_0_4, '0']
- [iir_filter_xxx_0_0_2, '0', iir_filter_xxx_0_0_2_1, '0']
- [iir_filter_xxx_0_0_2_0, '0', iir_filter_xxx_0_0_2_0_0, '0']
- [iir_filter_xxx_0_0_2_0_0, '0', rational_resampler_xxx_0_0_0_1, '0']
- [iir_filter_xxx_0_0_2_1, '0', rational_resampler_xxx_0_0_0_5, '0']
- [iir_filter_xxx_0_0_3, '0', rational_resampler_xxx_0_0_0_3, '0']
- [rational_resampler_xxx_0_0, '0', blocks_file_sink_0_0_2, '0']
- [rational_resampler_xxx_0_0, '0', network_udp_sink_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_sink_x_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', network_udp_sink_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_file_sink_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', network_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', blocks_file_sink_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', network_udp_sink_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', qtgui_sink_x_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', blocks_file_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', network_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', qtgui_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_4, '0', blocks_file_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_4, '0', network_udp_sink_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_4, '0', qtgui_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_5, '0', blocks_file_sink_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_5, '0', network_udp_sink_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_5, '0', qtgui_sink_x_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_6, '0', blocks_file_sink_0_0_2_1, '0']
- [rational_resampler_xxx_0_0_0_6, '0', network_udp_sink_0_0_1_0_0, '0']
- [rational_resampler_xxx_0_0_0_6, '0', qtgui_sink_x_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_6_0, '0', blocks_file_sink_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_6_0, '0', network_udp_sink_0_0_1_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_6_0, '0', qtgui_sink_x_0_0_0_0_1_1, '0']
- [rational_resampler_xxx_0_0_0_6_1, '0', blocks_file_sink_0_0_2_0, '0']
- [rational_resampler_xxx_0_0_0_6_1, '0', network_udp_sink_0_0_1_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_6_1, '0', qtgui_sink_x_0_0_0_0_1_2, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
