options:
  parameters:
    author: Patron
    generate_options: qt_gui
    id: Chan1_500k_HackRF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\all_SF1
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\all_SF1
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: 903.3e6
    gain: '12'
    samp_rate: samp_rate
    type: fc32
    vga: '12'
  states: {}

connections:
- [blocks_correctiq_0, '0', blocks_file_sink_0_0, '0']
- [blocks_correctiq_0, '0', network_udp_sink_0_0_0, '0']
- [blocks_correctiq_0, '0', qtgui_sink_x_0_0_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
