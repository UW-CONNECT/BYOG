options:
  parameters:
    author: Patron
    generate_options: qt_gui
    id: Chan4_2M_RTLSDR
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FBtaps
  id: variable
  parameters:
    value: '[1, -3.74412118,  5.30709176, -3.37351017,  0.81112777]'
  states: {}
- name: FFtaps
  id: variable
  parameters:
    value: '[8.98440143e-05, 9.54644754e-05, 1.53599431e-04, 9.54644754e-05, 8.98440143e-05]'
  states: {}
- name: FSby2
  id: variable
  parameters:
    value: samp_rate_0/(2e6)
  states: {}
- name: M_PI
  id: variable
  parameters:
    value: '3.14159265358979323846'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 2000e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\test
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C5
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C4
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C7
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\C6
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.1 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.1 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (0.3 * M_PI) / FSby2
  states: {}
- name: blocks_rotator_cc_0_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-0.3 * M_PI) / FSby2
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_2
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_3
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2010'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '1998'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5100'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '128'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_3
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_4
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: 903.2e6
    gain0: '35'
    gain_mode0: 'False'
    if_gain0: '35'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_rotator_cc_0, '0', iir_filter_xxx_0_0_0, '0']
- [blocks_rotator_cc_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_rotator_cc_0_0_0, '0', iir_filter_xxx_0_0_1, '0']
- [blocks_rotator_cc_0_0_0_0, '0', iir_filter_xxx_0_0_1_0, '0']
- [iir_filter_xxx_0_0, '0', iir_filter_xxx_0_0_3, '0']
- [iir_filter_xxx_0_0_0, '0', iir_filter_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0_0_1, '0', iir_filter_xxx_0_0_1_2, '0']
- [iir_filter_xxx_0_0_1_0, '0', iir_filter_xxx_0_0_1_0_0, '0']
- [iir_filter_xxx_0_0_1_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [iir_filter_xxx_0_0_1_2, '0', rational_resampler_xxx_0_0_0_4, '0']
- [iir_filter_xxx_0_0_3, '0', rational_resampler_xxx_0_0_0_3, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', network_udp_sink_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_file_sink_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', network_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', blocks_file_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', network_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', qtgui_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_4, '0', blocks_file_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_4, '0', network_udp_sink_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_4, '0', qtgui_sink_x_0_0_0_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
