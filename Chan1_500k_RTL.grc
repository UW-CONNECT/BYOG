options:
  parameters:
    author: Patron
    generate_options: qt_gui
    id: Chan1_500k_RTL
    output_language: python
    title: ID
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\all_SF1
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Patron\Downloads\SF_BW_EST\all_SF1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 125 / 128
    type: complex
  states: {}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '128'
    interp: '125'
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: 903.3e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', network_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_0_0_0_1, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
